# Keil uVision project USBD_VCOM_And_HID_Transfer.uvprojx, settings and files
target USBD_VCOM_And_HID_Transfer (6160000::V6.16::ARMCLANG)
  device: M258KE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.14
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: USBD_VCOM_And_HID_Transfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\GoodWay
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group User
    ../: descriptors.c main.c
    ../../../../GoodWay/: GW_led.c GW_touch.c GW_aw5808.c GW_menu.c GW_FMC_IAP_APROM.c GW_ldrom.s GW_hid_manage.c GW_hid_app.c GW_wm8804_cs8422.c GW_hid_vcom_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: timer.c retarget.c usbd.c sys.c clk.c uart.c spi.c rtc.c i2c.c pdma.c gpio.c usci_i2c.c fmc.c eadc.c
